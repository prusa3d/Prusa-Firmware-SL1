PACKAGECONFIG_CONFARGS_append = " -no-sql-psql"
