RDEPENDS_${PN}_remove += " \
    qttranslations-qt \
"
