PACKAGECONFIG_class-nativesdk = ""
