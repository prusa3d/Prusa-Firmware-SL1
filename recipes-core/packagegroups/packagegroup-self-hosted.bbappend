RDEPENDS_packagegroup-self-hosted-extended_remove = "mdadm"
