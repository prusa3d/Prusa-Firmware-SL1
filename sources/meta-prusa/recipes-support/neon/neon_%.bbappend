BINCONFIG = ""

inherit binconfig
