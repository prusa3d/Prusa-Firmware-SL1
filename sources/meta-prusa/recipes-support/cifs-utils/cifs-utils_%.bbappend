
PACKAGECONFIG ??= "usr"
PACKAGECONFIG[usr] = "ROOTSBINDIR=${sbindir},"
