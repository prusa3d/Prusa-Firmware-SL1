EXTRA_OECONF:append = "\
	--with-librt-prefix=${STAGING_DIR_HOST}${prefix} \
"
