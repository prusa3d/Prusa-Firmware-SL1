require extra-cmake-modules.inc
SRCREV = "v${PV}"
