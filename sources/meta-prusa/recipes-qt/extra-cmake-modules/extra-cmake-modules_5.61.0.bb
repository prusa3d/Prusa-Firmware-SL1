require ${PN}.inc
SRCREV = "v${PV}"
