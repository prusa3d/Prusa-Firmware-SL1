FILESEXTRAPATHS:prepend := "${FILE_DIRNAME}/${PN}:"
SRC_URI:append = " file://CVE-2021-45930.patch"
