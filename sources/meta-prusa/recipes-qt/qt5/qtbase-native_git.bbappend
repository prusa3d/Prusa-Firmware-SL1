PACKAGECONFIG_CONFARGS:append = " -no-sql-psql"
