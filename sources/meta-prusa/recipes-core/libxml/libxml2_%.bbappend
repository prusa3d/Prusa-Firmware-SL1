PACKAGECONFIG:class-nativesdk = ""
