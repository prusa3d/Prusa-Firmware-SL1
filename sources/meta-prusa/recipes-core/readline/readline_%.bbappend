FILESEXTRAPATHS_prepend := "${THISDIR}/readline:"

SRC_URI+="\
	file://inputrc \
"
