RDEPENDS:packagegroup-self-hosted-extended:remove = "mdadm"
