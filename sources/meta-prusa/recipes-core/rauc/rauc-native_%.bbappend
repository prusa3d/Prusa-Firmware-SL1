RDEPENDS_${PN}_append = " libp11-native"
