PACKAGECONFIG:remove = "nvdimm python3 lvm-dbus lvm dm dmraid kmod escrow btrfs kbd mpath"

DEPENDS += "kmod udev"

