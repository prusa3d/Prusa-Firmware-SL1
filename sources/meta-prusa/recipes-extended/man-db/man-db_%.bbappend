EXTRA_OECONF_append = " --with-systemdsystemunitdir=${systemd_system_unitdir} "
