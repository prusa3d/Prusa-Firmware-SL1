require avrdude.inc

SRC_URI[sha256sum] = "0f9f731b6394ca7795b88359689a7fa1fba818c6e1d962513eb28da670e0a196"
