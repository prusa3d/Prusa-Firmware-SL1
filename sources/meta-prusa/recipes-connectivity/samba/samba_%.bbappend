FILESEXTRAPATHS:prepend := "${THISDIR}/samba:"

SRC_URI += "file://smb.conf"
