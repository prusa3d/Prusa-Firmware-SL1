FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
        file://0001-ignore-legacy-unicast-drop.patch \
"

