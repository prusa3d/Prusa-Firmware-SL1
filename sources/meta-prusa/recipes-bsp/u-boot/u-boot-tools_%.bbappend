require u-boot-srcrev.inc
