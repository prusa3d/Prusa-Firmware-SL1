EXTRA_OECONF:append = " --disable-capstone "
