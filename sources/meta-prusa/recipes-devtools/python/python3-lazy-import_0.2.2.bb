inherit pypi setuptools3

DESCRIPTION = "lazy_import provides a set of functions that load modules, and related attributes, in a lazy fashion."
SECTION = "base"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://README.rst;md5=66354545d563c99dea56ae5e49abb259"

SRC_URI[md5sum] = "564449119705a15eb288fa94d21b018a"
SRC_URI[sha256sum] = "2149aef8579459407c62cfeccf118527939c9931ace124f355236360644f8a3d"

PYPI_PACKAGE = "lazy_import"
PYPI_PACKAGE_EXT = "tar.gz"
