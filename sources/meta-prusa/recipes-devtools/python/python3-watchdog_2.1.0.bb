inherit pypi setuptools3

SUMMARY = "Filesystem events monitoring"
HOMEPAGE = "https://github.com/gorakhargosh/watchdog"
AUTHOR = "Yesudeep Mangalapilly <yesudeep@gmail.com>"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=30daa2dd44aca3060ff441d27a947dd2"

SRC_URI[md5sum] = "008a62c2b379b1b144ec07ed6cd34266"
SRC_URI[sha256sum] = "55316efab52f659b8b7b59730680bfb27ac003522f24c44f6bcd60c4e3736ccd"

PYPI_PACKAGE = "watchdog"
PYPI_PACKAGE_EXT = "tar.gz"
