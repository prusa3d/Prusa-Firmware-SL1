inherit pypi setuptools3

SUMMARY = "Streaming parser for multipart/form-data"
HOMEPAGE = "https://github.com/siddhantgoel/streaming-form-data"
AUTHOR = "Siddhant Goel <me@sgoel.org>"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=5f4c4303d9514b6ca179db4379deda83"

SRC_URI[md5sum] = "e5fbf216d8696972da1d1a90d46c74bd"
SRC_URI[sha256sum] = "20f6b8371587b960b43baee4de63f7d33c67919e199dea416d835611a0edcaca"

PYPI_PACKAGE = "streaming-form-data"
PYPI_PACKAGE_EXT = "tar.gz"
