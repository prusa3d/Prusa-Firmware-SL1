inherit pypi setuptools3

SUMMARY = "Deprecated is Easy to Use"
DESCRIPTION = "If you need to mark a function or a method as deprecated, you can use the @deprecated decorator."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=2fa8e553e801a559538161a8e53b9525"

SRC_URI[md5sum] = "93d65f6a4efc9aebebfd28c9413dfd19"
SRC_URI[sha256sum] = "408038ab5fdeca67554e8f6742d1521cd3cd0ee0ff9d47f29318a4f4da31c308"

PYPI_PACKAGE = "Deprecated"

