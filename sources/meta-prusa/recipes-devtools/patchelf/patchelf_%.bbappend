SRC_URI:remove = "file://handle-read-only-files.patch"
