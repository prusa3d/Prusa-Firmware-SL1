 
require ${PN}.inc
SRCREV = "${PV}"