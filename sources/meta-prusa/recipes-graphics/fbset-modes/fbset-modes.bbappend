FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI = " \
	file://fb.modes \
"
