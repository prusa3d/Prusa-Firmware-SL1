RDEPENDS_${PN}-dev = ""
