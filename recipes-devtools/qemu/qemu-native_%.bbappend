EXTRA_OECONF_append = " --disable-capstone "
