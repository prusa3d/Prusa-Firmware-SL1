DESCRIPTION = "A Python remote procedure call framework that uses JSON RPC v2.0"
HOMEPAGE = "https://pypi.org/project/python-jrpc/"
SECTION = "devel/python"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD-3-Clause;md5=550794465ba0ec5312d6919e203a55f9"

PYPI_PACKAGE = "python-jrpc"

SRC_URI[md5sum] = "05b92012f2b3d954a80d950da165b454"
SRC_URI[sha256sum] = "4faec0d7fcc398a94aa6441ab51e5332ed0109feaf54056cfe71a4682eb0b58e"

inherit pypi setuptools
