PACKAGECONFIG_remove = "nvdimm"

DEPENDS += "kmod udev"
