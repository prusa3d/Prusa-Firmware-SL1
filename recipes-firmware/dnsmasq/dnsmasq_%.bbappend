FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://dnsmasq.conf \
"
